# Keil uVision project MiniScope.uvproj, settings and files
target MiniScope (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: MiniScope +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __CX51__
  c include: .\include
  link misc: REMOVEUNUSED
  group lib/startup
    ../Libraries/Core/Startup/STC8x/: startup_stc8a.s
  group user
    ./src/user/: main.c
